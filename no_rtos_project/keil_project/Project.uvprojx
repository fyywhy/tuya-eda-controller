# Keil uVision project Project.uvprojx, settings and files
target tuya_wifi_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\firmware\GD32F10x_standard_peripheral\Include;..\firmware\CMSIS\GD\GD32F10x\Include;..\firmware\CMSIS;..\;..\driver;..\tuya_wifi_sdk;..\application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../application/: main.c systick.c gd32f10x_it.c
  group Driver
    ../driver/: led.c i2c.c oled.c serial.c sht30.c drv_ctrl.c gd25qxx.c mcu_info.c
  group Wifi_SDK
    ../tuya_wifi_sdk/: mcu_api.c protocol.c system.c
  group CMSIS
    ../firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
